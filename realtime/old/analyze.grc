<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>analyze</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>infile</value></param>
<param><key>label</key><value>Input File</value></param>
<param><key>value</key><value>data</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>i</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>value</key><value>1000000</value></param>
<param><key>type</key><value>long</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>outfile</value></param>
<param><key>label</key><value>Output File</value></param>
<param><key>value</key><value>data.wav</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>o</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>amp</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>amp</value></param>
<param><key>label</key><value>Amplification</value></param>
<param><key>value</key><value>70</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>outfile</value></param>
<param><key>nchan</key><value>3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<block>
<key>gr_complex_to_mag</key>
<param><key>id</key><value>gr_complex_to_mag_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_complex_to_float</key>
<param><key>id</key><value>gr_complex_to_float_0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_file_source</key>
<param><key>id</key><value>gr_file_source_0</value></param>
<param><key>file</key><value>infile</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_file_source_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_complex_to_mag_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_complex_to_float_0</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
